# Keil uVision project RM战车.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM战车 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx
  c misc: --c99
  c include: .\STLibrary;.\USER;.\BSP;.\MPU6050;.\Task;.\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./USER/: main.c
  group BSP
    ./BSP/: led.c delay.c timer.c usart1.c usart3.c can1.c flash.c gun.c bsp.c encoder.c spi.c usart2.c exti.c
    ../../../../zh工程车加电磁阀/RM战车2.0新主控板标准库版/BSP/: can2.c
  group Libraries
    ./STLibrary/: system_stm32f4xx.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_sdio.c stm32f4xx_rcc.c stm32f4xx_i2c.c stm32f4xx_gpio.c stm32f4xx_flash.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_crc.c stm32f4xx_can.c stm32f4xx_adc.c misc.c stm32f4xx_it.c startup_stm32f4xx.s stm32f4xx_spi.c
  group MPU6050
    ./MPU6050/: imu.c mpu6500_interrupt.c test_imu.c
  group Task
    ./Task/: CanBusTask.c ControlTask.c IOTask.c RemoteTask.c SuperviseTask.c PID.c lost_counter.c Ramp.c Protocol.c
  group HARDWARE
    ./HARDWARE/: door.c
software components: CMSIS:CORE 5.0.1
